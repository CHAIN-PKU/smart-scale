# Keil uVision project chengzhong.uvprojx, settings and files
target chengzhong (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: chengzhong +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c misc: --no-multibyte-chars
  c include: .\Core\Inc;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Core
    ./Core/Src/: main.c hx711.c scale.c protocol.c stm32f1xx_it.c stm32f1xx_hal_msp.c key.c voice.c wifi.c tft.c
    ./Core/Inc/: config.h main.h hx711.h scale.h protocol.h stm32f1xx_hal_conf.h stm32f1xx_it.h key.h voice.h wifi.h tft.h tft_font.h
  group Drivers/CMSIS
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f107xc.s
    ./Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
